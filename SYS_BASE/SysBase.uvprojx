# Keil uVision project SysBase.uvprojx, settings and files
target System (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SysBase +hex
  c flags: Optim=1 wLevel=2
  c include: .\SRC\APP;.\SRC\CMSIS;.\SRC\StdLib\inc;.\SRC\FreeRtos\include;.\SRC\FreeRtos\portable\ARM_CM3;.\SRC\Driver;.\SRC\MLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./SRC/APP/: main.c stm32f10x_it.c
  group FreeRtos
    ./SRC/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c heap_2.c
    ./SRC/FreeRtos/portable/ARM_CM3/: port.c
  group MLIB
    ./SRC/MLIB/: WM_Config.c
  group Driver
    ./SRC/Driver/: ili9320.c ili932x.c ili9320_api.c ili9320_touch.c
  group StdLib
    ./SRC/StdLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./SRC/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
